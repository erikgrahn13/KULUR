<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\KULUR.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\Test\testKULUR.ewp</path>
  </project>
  <batchBuild/>
</workspace>


